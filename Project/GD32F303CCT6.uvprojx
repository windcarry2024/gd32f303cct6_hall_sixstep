# Keil uVision project GD32F303CCT6.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.6.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303CCT6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_HD
  c include: ..\Firmware\CMSIS\GD\GD32F30x\Include;..\Firmware\CMSIS;..\Firmware\GD32F30x_standard_peripheral\Include;..\User;..\User\service;D:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Library
    ../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_misc.c gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_adc.c gd32f30x_dma.c gd32f30x_exti.c gd32f30x_pmu.c gd32f30x_usart.c gd32f30x_timer.c
  group Service
    ../User/service/: btn1.c btn1.h ctrl.c ctrl.h led.c led.h sysck.c sysck.h timing.c timing.h bldc.c bldc.h hall.c hall.h adc.c adc.h
  group Core
    ../User/: main.c main.h gd32f30x_it.c gd32f30x_it.h gd32f30x_libopt.h
    ../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
